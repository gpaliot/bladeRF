<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bladerf_nfm_rx</value></param>
<param><key>title</key><value>bladeRF NBFM Receiver</value></param>
<param><key>author</key><value>W2XH</value></param>
<param><key>description</key><value>Dual-channel Narrowband FM receiver for the nuand BladeRF</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>width/2</value></param>
<param><key>width</key><value>trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0</value></param>
<param><key>threshold</key><value>sql_lev</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>af_gain</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>width/2</value></param>
<param><key>width</key><value>trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0_0</value></param>
<param><key>threshold</key><value>sql_lev</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>blks2_nbfm_rx</key>
<param><key>id</key><value>blks2_nbfm_rx_0_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>af_gain</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>display_selector</value></param>
<param><key>label</key><value>Spectrum</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[0, 1]</value></param>
<param><key>labels</key><value>['Baseband','RF']</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>width</value></param>
<param><key>label</key><value>Filter</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>min</key><value>2000</value></param>
<param><key>max</key><value>40000</value></param>
<param><key>num_steps</key><value>760</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>8,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>label</key><value>RF</value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>-5</value></param>
<param><key>max</key><value>30</value></param>
<param><key>num_steps</key><value>35</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>9,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>trans</value></param>
<param><key>label</key><value>Trans</value></param>
<param><key>value</key><value>1500</value></param>
<param><key>min</key><value>500</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>900</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>8,1,1,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>label</key><value>VOL</value></param>
<param><key>value</key><value>5</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>11</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>9,3,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sql_lev</value></param>
<param><key>label</key><value>SQL</value></param>
<param><key>value</key><value>-40</value></param>
<param><key>min</key><value>-80</value></param>
<param><key>max</key><value>0</value></param>
<param><key>num_steps</key><value>500</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>9,1,1,2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, samp_rate/2, 5000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_freq</value></param>
<param><key>value</key><value>(freq + freq_sec) / 2.0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_sec</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>center_freq</key><value>shift_sec</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_main</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>center_freq</key><value>shift_main</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>fftsink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>tune_freq*display_selector</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>20</value></param>
<param><key>ref_scale</key><value>1.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>500, 300</value></param>
<param><key>grid_pos</key><value>0,0,5,4</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>osmosdr_source_c</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>tune_freq</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>0</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>gain0</key><value>6</value></param>
<param><key>if_gain0</key><value>rf_gain</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Main Freq</value></param>
<param><key>value</key><value>444.250e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>6,0,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq_sec</value></param>
<param><key>label</key><value>Sec Freq</value></param>
<param><key>value</key><value>444.400e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>7,0,1,1</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>tune_freq*display_selector</value></param>
<param><key>dynamic_range</key><value>70</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>500, 300</value></param>
<param><key>grid_pos</key><value>0, 4, 5, 4</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blks2_nbfm_rx</key>
<param><key>id</key><value>blks2_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_coarse</value></param>
<param><key>label</key><value>Coarse tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-48000</value></param>
<param><key>max</key><value>48000</value></param>
<param><key>num_steps</key><value>960</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,1,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_coarse_sec</value></param>
<param><key>label</key><value>Coarse tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-48000</value></param>
<param><key>max</key><value>48000</value></param>
<param><key>num_steps</key><value>960</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,1,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_fine</value></param>
<param><key>label</key><value>Fine tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-1000</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>400</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,2,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_fine_sec</value></param>
<param><key>label</key><value>Fine tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-1000</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>400</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,2,1,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>Main RX</value></param>
<param><key>value</key><value>tune_freq+shift_main</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>6,3,1,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>rx_freq_sec</value></param>
<param><key>label</key><value>Sec RX</value></param>
<param><key>value</key><value>tune_freq+shift_sec</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>7,3,1,1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shift_sec</value></param>
<param><key>value</key><value>min(samp_rate/2, max(-samp_rate/2, (freq_sec-tune_freq)+(offset_coarse_sec+offset_fine_sec)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shift_main</value></param>
<param><key>value</key><value>min(samp_rate/2, max(-samp_rate/2, (freq-tune_freq)+(offset_coarse+offset_fine)))</value></param>
</block>
<block>
<key>wxgui_constellationsink2</key>
<param><key>id</key><value>wxgui_constellationsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>title</key><value>Constellation Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>frame_rate</key><value>5</value></param>
<param><key>const_size</key><value>2048</value></param>
<param><key>M</key><value>4</value></param>
<param><key>theta</key><value>0</value></param>
<param><key>loop_bw</key><value>6.28/100.0</value></param>
<param><key>fmax</key><value>0.06</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>0.005</value></param>
<param><key>symbol_rate</key><value>samp_rate/4.</value></param>
<param><key>omega_limit</key><value>0.005</value></param>
<param><key>win_size</key><value>500, 300</value></param>
<param><key>grid_pos</key><value>5,4,6,4</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>cheesy_greeting</value></param>
<param><key>label</key><value>bladeRF Dual NBFM Receiver by W2XH</value></param>
<param><key>value</key><value>"Running"</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>10,0,1,4</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>int(96e3*4)</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,2,1,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>tune_freq_show</value></param>
<param><key>label</key><value>Center Freq</value></param>
<param><key>value</key><value>tune_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,3,1,1</value></param>
</block>
<connection><source_block_id>blks2_nbfm_rx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0</source_block_id><sink_block_id>blks2_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter</source_block_id><sink_block_id>analog_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_nbfm_rx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0_0</source_block_id><sink_block_id>blks2_nbfm_rx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_simple_squelch_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_sec</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_main</source_block_id><sink_block_id>low_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_main</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_sec</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_constellationsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fftsink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
