<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bladerf_nfm_tx</value></param>
<param><key>title</key><value>Example NBFM transmitter</value></param>
<param><key>author</key><value>W2XH</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>446.66e6</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/rtucker/Dropbox/tmp/w2xh_id.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_fine</value></param>
<param><key>label</key><value>Fine tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-1000</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>400</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,0,1,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_coarse</value></param>
<param><key>label</key><value>Coarse tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-48000</value></param>
<param><key>max</key><value>48000</value></param>
<param><key>num_steps</key><value>960</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,2,1,2</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>selector_input</value></param>
<param><key>label</key><value>Audio</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0, 1]</value></param>
<param><key>labels</key><value>["wav", "tone"]</value></param>
<param><key>type</key><value>button</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96e3</value></param>
</block>
<block>
<key>blks2_nbfm_tx</key>
<param><key>id</key><value>blks2_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>int(48e3)</value></param>
<param><key>quad_rate</key><value>int(samp_rate)</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>osmosdr_sink_c</key>
<param><key>id</key><value>osmosdr_sink_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>samp_rate*interp</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>1.5e6</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>selector_input</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate/2</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate/2</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>interp</key><value>interp</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>5e3</value></param>
<param><key>width</key><value>1.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_nbfm_tx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>osmosdr_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
